Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: C:\Users\Usuario\Desktop\JOMBAR\MUESTRAS B.I.M\IFC\ATLAS\NIVEL 01\ATBASi150050030.ifc
Time: 2017-02-20T20:33:15
Written by: ACCA_IFC.dll Version 200
Made in: Edificius 8.00c

# IfcSite, Default Site
RefLatitude: 0, 0, 0; RefLongitude: 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey (4)
In: Default Building
Name | Elevation (mm) | NominalHeight (mm)
TERRENO | -1500 | 1000
Cimentación | -500 | 500
Planta Baja | 0 | 3200
Cubierta | 3200 | 0

# IfcFurnishingElement: CALZO BASE ATLAS 500 30, CALZO BASE ATLAS
In: Planta Baja
Description: CALZO BASE ATLAS NIVEL 01; Material: Color_01
PROPIEDADES GENERALES - COMPOSICIÓN: COMPOSITE POLIETILENO; COLOR: NEGRO; PESO POR UNIDAD: 7200 g; TEMPERATURA MÁXIMA DE ALMACENAMIENTO: 60º C
Pset_ManufacturerTypeInformation - ArticleNumber: CALZO BASE ATLAS NIVEL 01; ModelReference: ATBASi150050030; ModelLabel: ATBASi150050030; Manufacturer: JOMBAR; ProductionYear: 2017
